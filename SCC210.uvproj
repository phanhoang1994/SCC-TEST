# Keil uVision project SCC210.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123AE6PM Texas Instruments
  cpu: IROM(0x00000000,0x020000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: SCC210 +hex
  c flags: Optim=3 uC99=1 wLevel=2
  c define: rvmdk PART_TM4C123AE6PM TARGET_IS_TM4C123_RB1
  c include: .\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: can.c main.c sysclock.c startup_rvmdk.S function.c uart4.c
  group Lib
    ./ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
  group inc
    ./: can_scc.h function.h global.h sysclock.h uart4.h
